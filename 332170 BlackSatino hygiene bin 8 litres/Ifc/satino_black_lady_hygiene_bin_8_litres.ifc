Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: satino_black_lady_hygiene_bin_8_litres.ifc
Time: 2017-07-18T09:42:25
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Satino Black lady hygiene bin 8 litres
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Satino Black lady hygiene bin 8 litres; SKU (BO_prodsku): 180322; ManufacturName (BO_Manufac): Satino Black; BrandUrl (BO_brandurl): http://www.vanhoutum.nl/en/brands/5195/satino-black.html; ProductFamily (BO_prodfam): Sanitary; ProductGroup (BO_prodgroup): Bin; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 260; Height (BO_height): 370; Depth (BO_depth): 180; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/satinoblack/product/180322; ProductDataUrl (BO_prodaturl): bimobject.com/satinoblack/product/180322; ProductUrl (BO_producturl): http://www.vanhoutum.nl/en/product-range/products/7829/satino-black-ladybin-8-liter.html?referrer=%2fen%2fproduct-range%2f5187%2fproducts.html%3fs%3d4995; EanCode (BO_ean): 8710561006046; MaterialMain (BO_mainmat): Plastic; BimObjectCategory (BO_bocat): Dispensers; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L8244; Uniclass14Description (BO_uniclass_1_4_desc): Sanitary dispensers; Uniclass20Code (BO_uniclass_2_0_code): PR-35-76-75; Uniclass20Description (BO_uniclass_2_0_desc): Sanitary Towel Dispensers; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_22; Uniclass2015Description (BO_uniclass2015_desc): Dispensers and acceptance units; NBSReference (BO_nbs_ref): 35-76-75; NBSReferenceDescription (BO_nbs_desc): Sanitary Towel Dispensers; OmniClassCode (BO_omniclass_code): 23-31 25 23 11; OmniClassDescription (BO_omniclass_name): Sanitary Napkin Dispensers; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
